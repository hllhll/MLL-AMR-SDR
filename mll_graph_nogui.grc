options:
  parameters:
    author: hillel.ch
    generate_options: qt_gui
    id: record_decode_433
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: acquire
  id: variable
  parameters:
    value: 18*decoding_samp_per_sym
  states: {}
- name: available_bw
  id: variable
  parameters:
    value: samp_rate_cap-offset_tune*2
  states: {}
- name: cap_sps
  id: variable
  parameters:
    value: int(samp_rate_cap/sym_rate)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(465.6e6)
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      465624750
      465.62-465.64
      465.625
    orient: Qt.Horizontal
    start: int(433e6)
    step: '50'
    stop: int(434e6)
    value: int(433.9e6)
  states: {state: disabled}
- name: center_tune_freq
  id: variable
  parameters:
    value: center_freq-offset_tune
  states: {}
- name: channel_0_freq
  id: variable
  parameters:
    value: '433049000'
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: channel_0_freq+(channel_num*250000)
  states: {state: disabled}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: center_tune_freq-(available_bw/2)
    step: '500'
    stop: center_tune_freq+(available_bw/2)
    value: '465625000'
  states: {state: disabled}
- name: channel_freq
  id: variable
  parameters:
    value: '465625000'
  states: {}
- name: channel_num
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '5'
    value: '5'
  states: {state: disabled}
- name: channel_shift
  id: variable
  parameters:
    value: channel_freq-center_freq
  states: {}
- name: constellation_4fsk
  id: variable_constellation
  parameters:
    const_points: '[-1.5,-0.5,0.5,1.5]'
    dims: '1'
    precision: '2'
    rot_sym: '2'
    soft_dec_lut: '"auto"'
    sym_map: '[0, 2, 4, 6]'
    type: calcdist
  states: {}
- name: decoding_samp_per_sym
  id: variable
  parameters:
    value: cap_sps
  states: {state: disabled}
- name: decoding_samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: decoding_samp_rate
  id: variable
  parameters:
    value: (sym_rate*decoding_samp_per_sym)
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    comment: gnuradio dude:700, 2100
    value: '600'
  states: {}
- name: lbl_channel_freq
  id: variable_qtgui_label
  parameters:
    label: lbl_channel_freq
    type: real
    value: channel_freq/1000000
  states: {state: disabled}
- name: min_power_db
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-80'
    step: '0.1'
    stop: '1'
    value: '-56.000'
  states: {state: disabled}
- name: offset_tune
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate_cap
  id: variable
  parameters:
    comment: |-
      From my old capture, it seems like 6 channels
      are around 2.048M-250k, spanning ~1.5M,
      roughly 200k between each channel
    value: 0.250e6
  states: {}
- name: signal_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      465624750
      465.62-465.64
      465.625
    orient: Qt.Horizontal
    start: int(433e6)
    step: '50'
    stop: int(434e6)
    value: int(433.9e6)
  states: {state: disabled}
- name: sym_rate
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: sync_damping
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.001'
    stop: '3'
    value: '1'
  states: {state: disabled}
- name: sync_loop_bw
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.00001'
    step: '0.00001'
    stop: '1'
    value: '0.48782'
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-56.000'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_1_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      this is the real formula
      samp_rate/(2*math.pi*fsk_deviation_hz)
    gain: decoding_samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_1_0_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      this is the real formula
      samp_rate/(2*math.pi*fsk_deviation_hz)
    gain: samp_rate_cap/(2*math.pi*fsk_deviation_hz)
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset_tune'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_cap
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-channel_shift'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_cap
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-3'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Donno Y this is the
      calculation that turned out currect
    delay: (acquire-1)*2
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: C:\hll\miltel_no_fhss\on_premis_433\10_Live\live8_overnight_48k
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      NURadio constellation object autoscales your
      constellation so that the symbol levels have a mean magnitude of 1.0.
      (e.g. 4FSK levels would be +/-0.5 and +/-1.5.
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Wide offset tune
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: channel select
    type: complex
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: decoding_samp_per_sym
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: decoding_samp_rate
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 0.0.0.0
    noblock: 'False'
    port: '55525'
    type: byte
    vlen: '1'
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: acquire
    long_form: 'True'
    type: ff
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_4fsk
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    constellation: constellation_4fsk
    damping: '1'
    loop_bw: '0.48782'
    max_dev: '1.2'
    osps: '1'
    pfb_mf_taps: '[128]'
    resamp_type: digital.IR_MMSE_8TAP
    sps: decoding_samp_per_sym
    ted_gain: '1.5'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, reset_tag=\"\", reset_tag_value=\"\", lock_time=20, end_tag=\"\"):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Tagged burst frequency lock',   # will show up in GRC\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n\n        self._reset_tag = reset_tag\n        self._reset_tag_value = reset_tag_value\n        self._lock_len = lock_time\n        self._end_tag = end_tag\n        self._reset()\n\n    def get_tag_rel_offsets(self, data, inpnum, tagname):\n    #def get_tags_rel_offsets(self, data, inpnum):\n        ret = []\n        tags = self.get_tags_in_window(inpnum, 0, len(data))\n        for tag in tags:\n            key = pmt.to_python(tag.key) # convert from PMT to python string\n            value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was\n            if key==tagname:\n                item ={\n                    'reloff': tag.offset - self.nitems_read(inpnum),\n                    'name': tagname\n                }\n                ret.append(item)\n        return ret\n\n    def get_start_tag_rel_offsets(self, data, inpnum):\n        return self.get_tag_rel_offsets( data, inpnum, self._reset_tag)\n\n    def get_end_tag_rel_offsets(self, data, inpnum):\n        return self.get_tag_rel_offsets( data, inpnum, self._end_tag)\n\n    def _reset(self):\n        self._state = 0\n        self._lock_counter = 0\n        self._lock_value = 0.0\n\n    def work(self, input_items, output_items):\n        signal = input_items[0]\n        dc_off = input_items[1]\n        # self.get_tags_in_window(which_input, rel_start, rel_end)\n        # Will return a list of tags for the current window (input items)\n        start_tag_poss = self.get_start_tag_rel_offsets(signal, 0)\n        end_tag_poss = self.get_end_tag_rel_offsets(signal, 0)\n        for i in range(len(signal)):\n            for tag in start_tag_poss:\n                if i==tag['reloff'] and tag['name']==self._reset_tag:\n                    # Reset detected\n                    self._reset()\n                    break # Next i\n\n            if self._state == 0: # Aquire\n                self._lock_counter += 1\n                if self._lock_counter == self._lock_len: # End aquire\n                    self._state = 1;\n                    self._lock_value = dc_off[i]\n                    #print(\"lock \" + str(self._lock_value))\n                output_items[0][i] = signal[i] - dc_off[i] # Plain DC Block\n            else:\n                # Lock DC Value\n                output_items[0][i] = signal[i] - self._lock_value\n        return len(output_items[0])\n\n\n"
    end_tag: '"''squelch_eob"'
    lock_time: 20*decoding_samp_per_sym
    reset_tag: '"squelch_sob"'
    reset_tag_value: '""'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tag Rewrite
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      log = gr.logger("TR")
      log.set_level("DEBUG")

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """TagRewrite - rewrite tag to any value"""

          def __init__(self, tag_name="", target_tag_name=""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Copy',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tag_name = pmt.intern(tag_name)
              self.target_tag_name = pmt.intern(target_tag_name)

              # pass through tags
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL )

              log.debug("TR init done")

          def work(self, input_items, output_items):
              """Update tag value"""
              output_items[0][:] = input_items[0]

              nr = len(input_items[0])
              tags = self.get_tags_in_window(0, 0, nr, self.tag_name)
              for tag in tags:
                  #value = pmt.to_python(tag.value)
                  self.add_item_tag(0, tag.offset, self.target_tag_name, tag.value)

              return len(output_items[0])
    tag_name: '"squelch_sob"'
    target_tag_name: '"burst"'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tag Rewrite
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      log = gr.logger("TR")
      log.set_level("DEBUG")

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """TagRewrite - rewrite tag to any value"""

          def __init__(self, tag_name="", target_tag_name=""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Copy',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tag_name = pmt.intern(tag_name)
              self.target_tag_name = pmt.intern(target_tag_name)

              # pass through tags
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL )

              log.debug("TR init done")

          def work(self, input_items, output_items):
              """Update tag value"""
              output_items[0][:] = input_items[0]

              nr = len(input_items[0])
              tags = self.get_tags_in_window(0, 0, nr, self.tag_name)
              for tag in tags:
                  #value = pmt.to_python(tag.value)
                  self.add_item_tag(0, tag.offset, self.target_tag_name, tag.value)

              return len(output_items[0])
    tag_name: '"squelch_eob"'
    target_tag_name: '"burst"'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tag Rewrite
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      log = gr.logger("TR")
      log.set_level("DEBUG")

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """TagRewrite - rewrite tag to any value"""

          def __init__(self, tag_name="", tag_value=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Rewrite',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tag_name = pmt.intern(tag_name)
              self.tag_value = pmt.intern(str(tag_value))

              # pass through tags
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL )

              log.debug("TR init done")

          def work(self, input_items, output_items):
              """Update tag value"""
              output_items[0][:] = input_items[0]

              nr = len(input_items[0])
              tags = self.get_tags_in_window(0, 0, nr, self.tag_name)
              for tag in tags:
                  self.add_item_tag(0, tag.offset, self.tag_name, self.tag_value)

              return len(output_items[0])
    tag_name: '"squelch_sob"'
    tag_value: 'True'
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tag Rewrite
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      log = gr.logger("TR")
      log.set_level("DEBUG")

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """TagRewrite - rewrite tag to any value"""

          def __init__(self, tag_name="", tag_value=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Rewrite',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tag_name = pmt.intern(tag_name)
              self.tag_value = pmt.intern(str(tag_value))

              # pass through tags
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL )

              log.debug("TR init done")

          def work(self, input_items, output_items):
              """Update tag value"""
              output_items[0][:] = input_items[0]

              nr = len(input_items[0])
              tags = self.get_tags_in_window(0, 0, nr, self.tag_name)
              for tag in tags:
                  self.add_item_tag(0, tag.offset, self.tag_name, self.tag_value)

              return len(output_items[0])
    tag_name: '"squelch_eob"'
    tag_value: 'False'
  states: {state: disabled}
- name: epy_block_2_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tag Rewrite
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      log = gr.logger("TR")
      log.set_level("DEBUG")

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """TagRewrite - rewrite tag to any value"""

          def __init__(self, tag_nameT="squelch_sob", tag_nameF="squelch_eob"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Manipulate',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tag_nameT = pmt.intern(tag_nameT)
              self.tag_nameF = pmt.intern(tag_nameF)

              # pass through tags
              self.set_tag_propagation_policy(gr.TPP_DONT )

              log.debug("TR init done")

          def work(self, input_items, output_items):
              """Update tag value"""
              output_items[0][:] = input_items[0]

              nr = len(input_items[0])
              tags = self.get_tags_in_window(0, 0, nr, self.tag_nameT)
              for tag in tags:
                  self.add_item_tag(0, tag.offset, pmt.intern(str("burst")), pmt.from_bool(True))
              tags = self.get_tags_in_window(0, 0, nr, self.tag_nameF)
              for tag in tags:
                  self.add_item_tag(0, tag.offset, pmt.intern(str("burst")), pmt.from_bool(False))
              return len(output_items[0])
    tag_nameF: '"squelch_eob"'
    tag_nameT: '"squelch_sob"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_cap
    type: fir_filter_ccf
    width: '3500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: decoding_samp_rate
    fc: channel_freq
    fftsize: 1024*6
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: raw_signal
    label2: dc_offset_magic
    nconnections: '2'
    size: 215*decoding_samp_per_sym
    srate: decoding_samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
    ymax: '10'
    ymin: '-10'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: raw_signal
    size: int(decoding_samp_rate*0.250)*3
    srate: samp_rate_cap
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '10'
    ymin: '-10'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 1024*5*3-3
    srate: decoding_samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: decoding_samp_per_sym*180
    srate: decoding_samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate_cap)
    fbw: '0.0001'
    interp: decoding_samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl_tcp=10.100.102.1"'
    bb_gain0: '9'
    freq0: center_tune_freq
    gain0: '38'
    gain_mode0: 'False'
    if_gain0: '8'
    sample_rate: samp_rate_cap
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0_0_0_1_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_file_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', epy_block_2, '0']
- [analog_pwr_squelch_xx_0, '0', epy_block_2_1, '0']
- [analog_quadrature_demod_cf_0_0_0_1_0, '0', blocks_delay_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_1_0, '0', dc_blocker_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_char_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_repeat_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_delay_0_0, '0', epy_block_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_char_1, '0', blocks_tcp_server_sink_0, '0']
- [blocks_float_to_complex_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_symbol_sync_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_repeat_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_sub_xx_0, '0', epy_block_0, '1']
- [dc_blocker_xx_0_0, '0', blocks_sub_xx_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_1, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_1, '0', epy_block_2_0, '0']
- [epy_block_1_0, '0', blocks_tagged_file_sink_0, '0']
- [epy_block_1_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_2, '0', epy_block_1, '0']
- [epy_block_2_0, '0', epy_block_1_0, '0']
- [epy_block_2_1, '0', blocks_tagged_file_sink_0, '0']
- [epy_block_2_1, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0_0_0_1_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
